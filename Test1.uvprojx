# Keil uVision project Test1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F031G4Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Test1
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS;.\CMSIS\inc;.\Code;.\Code\inc;..\ARGB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./CMSIS/src/: system_stm32f0xx.c startup_stm32f031x6.s
    ./CMSIS/inc/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_cm0.h core_cm0plus.h stm32f0xx.h stm32f031x6.h system_stm32f0xx.h
  group Code
    ./Code/src/: main.c
    ./Code/inc/: main.h
    ./: RCC.c RCC.h SYSTick.h SYSTick.c TIM1.c TIM1.h DMA.c DMA.h ADC.c ADC.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.3.3
